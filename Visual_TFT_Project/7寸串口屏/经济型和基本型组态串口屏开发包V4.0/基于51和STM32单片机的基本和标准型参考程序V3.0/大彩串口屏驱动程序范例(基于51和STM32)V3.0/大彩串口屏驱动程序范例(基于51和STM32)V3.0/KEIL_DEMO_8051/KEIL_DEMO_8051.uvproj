# Keil uVision project KEIL_DEMO_8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: 7.0TEST_DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: cmd_queue.c hmi_driver.c hmi_user_uart.c main.c STARTUP.A51 ulitity.c
